# IAR project Project.ewp, settings and files
configuration App (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030X8
  ICCARM.CCIncludePath2: ..\..\Source\App; ..\..\Source\Bsp; ..\..\Source\Components; ..\..\Source\Libraries\CMSIS\Device\startup\iar; ..\..\Source\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\Source\Libraries\CMSIS\Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_App.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f030x8_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/App/: dev_uart.c main.c system_stm32f0xx.c
  group BSP
    ../../Source/Bsp/: bsp_uart.c stm32f0xx_it.c
  group Components
    ../../Source/Components/: fifo.c
  group Libraries/Startup
    ../../Source/Libraries/CMSIS/Device/startup/iar/: startup_stm32f030.s
  group Libraries/STM32F0xx_StdPeriph_Driver
    ../../Source/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
