# IAR project Project.ewp, settings and files
configuration App (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Source\App; ..\..\Source\Bsp; ..\..\Source\Components; ..\..\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\RT-Thread\include; ..\..\Source\RT-Thread
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_App.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f1x_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/App/: dev_uart.c main.c
  group BSP
    ../../Source/Bsp/: bsp_uart.c stm32f10x_it.c
  group Components
    ../../Source/Components/: fifo.c
  group Libraries
    ../../Source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RT-Thread
    ../../Source/RT-Thread/: board.c rtconfig.h
    ../../Source/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../Source/RT-Thread/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
