# IAR project Project.ewp, settings and files
configuration App (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030X8
  ICCARM.CCIncludePath2: ..\..\Source\App; ..\..\Source\Bsp; ..\..\Source\Components; ..\..\Source\Libraries\CMSIS\Device\startup\iar; ..\..\Source\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\Source\Libraries\CMSIS\Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_App.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f1x_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/App/: dev_uart.c main.c
  group BSP
    ../../Source/Bsp/: bsp_uart.c
  group Components
    ../../Source/Components/: fifo.c
