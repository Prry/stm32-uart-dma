<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32h7-uart-dma.ewp</path>
  </project>
  <batchBuild />
</workspace>
